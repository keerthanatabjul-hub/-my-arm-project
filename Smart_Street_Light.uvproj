# Keil uVision project Smart_Street_Light.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Street_Light +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s types.h defines.h delay.h led.c pin_connect_block.c pin_fun_defines.h main.c app.c lcd.c kpm.c adc.c rtc.c date_utils.c streetlight.c eint.c delay.c rtc.h timer.c pwm.c scheduler.c config.c fault.c
